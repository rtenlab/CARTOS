# Keil uVision project cartos_example.uvprojx, settings and files
target freertos_tasks (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.1
  cpu: IRAM(0x10000000,0x002C0000) IROM(0x00018000,0x001E8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_tasks
  AfterMake: fromelf --bin --output bin\freertos_tasks.bin bin\freertos_tasks.axf
  AfterMake: fromelf -cedrst --output bin\freertos_tasks.txt bin\freertos_tasks.axf
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AM_PACKAGE_BGA  AM_FREERTOS AM_PART_APOLLO4P keil AM_UTIL_FAULTISR_PRINT
  c include: ../src;../../AmbiqSuiteFiles;../../AmbiqSuiteFiles/CMSIS/AmbiqMicro/Include;../../AmbiqSuiteFiles/CMSIS/ARM/Include;../../AmbiqSuiteFiles/utils;../../AmbiqSuiteFiles/devices;../../AmbiqSuiteFiles/mcu/apollo4p;../../AmbiqSuiteFiles/mcu/apollo4p/hal/mcu;../../AmbiqSuiteFiles/boards/apollo4p_blue_kbr_evb/bsp;../../CARTOS/Source/portable/Keil/AMapollo4;../../CARTOS/Source/include;../src/FFT;../src/CRC32;../src/sha;../src/stringsearch;../src/basicmath
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../AmbiqSuiteFiles/mcu/apollo4p/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c rtos.c freertos_tasks.c freertos.c adc_measure.c
  group devices
    ../../AmbiqSuiteFiles/devices/: am_devices_button.c am_devices_cooper.c am_devices_led.c
  group utils
    ../../AmbiqSuiteFiles/utils/: am_util_ble_cooper.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil
    ./: startup_keil.s
  group lib
    ../../AmbiqSuiteFiles/mcu/apollo4p/hal/mcu/keil/bin/: libam_hal.lib
    ../../AmbiqSuiteFiles//boards/apollo4p_blue_kbr_evb/bsp/keil/bin/: libam_bsp.lib
  group CARTOS_AMapollo4
    ../../CARTOS/Source/portable/Keil/AMapollo4/: port.c
  group CARTOS_MemMang
    ../../CARTOS/Source/portable/MemMang/: heap_4.c
  group CARTOS_Source
    ../../CARTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group Apps
    ../src/FFT/: fftmisc.c fourierf.c
    ../src/CRC32/: crc_32.c
    ../src/basicmath/: cubic.c isqrt.c rad2deg.c
    ../src/stringsearch/: bmhasrch.c bmhisrch.c bmhsrch.c
    ../src/sha/: sha.c
